Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-02-11T16:43:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.11.27 - Exporter 21.1.11.27 - Alternate UI 21.1.11.27
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 11 16:43:40 2021 * Host: URD0672 * Database: C:\Users\ZNLDNI01\AppData\Local\Temp\7f0592bd-7368-4a8d-ba13-31e93173eac0\22aa7787-3495-4956-b97e-014248931ec0\ifc * Database version: 5507 * Database creation date: Thu Feb 11 16:43:30 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 11 16:43:31 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 11 16:43:31 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 999999; RefLongitude: 12, 35, 59, 999999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Livello:Estremità 8 mm, Livello 1
LongName: Livello 1; Elevation: 0 mm

# IfcBuildingElementProxy: Electronics -Communication_Urmet_1083-20a:Electronics -Communication_Urmet_1083-20a, Electronics -Communication_Urmet_1083-20a:Electronics -Communication_Urmet_1083-20a:188436
In: Livello 1
Type - Classification: 1083/20A (Uniformat)
Type - Pset_BuildingElementProxyCommon - Reference: Electronics -Communication_Urmet_1083-20a
Type - Pset_ElementShading - Color: Grey RAL7035
Type - Pset_ManufacturerTypeInformation - Manufacturer: Urmet S.p.A. Urmet S.p.A.
Type - Pset_QuantityTakeOff - Reference: Electronics -Communication_Urmet_1083-20a
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK
